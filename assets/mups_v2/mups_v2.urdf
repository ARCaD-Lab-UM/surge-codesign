Commit message: Update config

File: assets/mups_v2/mups_v2.urdf (robot description, URDF)
Before this commit: robot mups_v2, 6 links, 5 joints
Links:
- link Foot: geometry collision cylinder length=0.2 radius=0.02; visual sphere radius=.021
