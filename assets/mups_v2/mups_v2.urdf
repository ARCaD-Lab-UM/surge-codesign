Commit message: Unify material color

File: assets/mups_v2/mups_v2.urdf (robot description, URDF)
Before this commit: robot leg_foot, 6 links, 5 joints
Links:
- link Foot: geometry collision cylinder length=0.05 radius=0.02; visual sphere radius=.021
